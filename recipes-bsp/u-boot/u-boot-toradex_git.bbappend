FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-configs-apalis-tk1-remove-spaces-from-DFU_ALT_EMMC_I.patch \
"
